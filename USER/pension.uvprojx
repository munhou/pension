# Keil uVision project pension.uvprojx, settings and files
target pension (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DHT11;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\WIFICONFIG;..\M8266WIFI;..\GLOBAL;..\HARDWARE\BUUZ_OUT;..\HARDWARE\HW_GUS_IN;..\HARDWARE\SDIO;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\MALLOC;..\HARDWARE\VS10XX;..\HARDWARE\SPI;..\HARDWARE\VS10XX;..\HARDWARE\SOUNDGET;..\HARDWARE\OV7670;..\HARDWARE\EXT;..\PICTURE;..\HARDWARE\BMP_SEND;..\PICTURE;..\HARDWARE\TIME;..\HARDWARE\OV7725
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/WIFICONFIG/: M8266_init.c
    ../HARDWARE/BUUZ_OUT/: BUUZ_OUT.c
    ../HARDWARE/HW_GUS_IN/: HW_GUS_IN.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/VS10XX/: vs10xx.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/SOUNDGET/: sound_get.c
    ../HARDWARE/OV7670/: sccb.c ov7670.c
    ../HARDWARE/EXT/: EXT.c
    ../HARDWARE/BMP_SEND/: BMP_SEND.c
    ../HARDWARE/TIME/: TIME.c
    ../HARDWARE/OV7725/: ov7725.c
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFI_ops.c test_m8266wifi.c M8266WIFIDrv_STM32F1xx.lib
  group GLOBAL
    ../GLOBAL/: GLOBAL.c
  group FATS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group MALLOC
    ../MALLOC/: malloc.c
  group PICTURE
    ../PICTURE/: bmp.c piclib.c
